# Keil uVision project C8.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: C8 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c include: ..\..\CORE;..\..\FWLIB;..\..\SYSTEM\inc;..\..\SYSTEM\src;..\..\USER;..\..\HARDWARE\LED;..\..\SYS\sys;..\..\SYS\delay;..\..\SYS\sys;..\..\HARDWARE\IIC;..\..\HARDWARE\OLED;..\..\HARDWARE\DS18B20;..\..\HARDWARE\KEY;..\..\HARDWARE\TIMER;..\..\HARDWARE\USART;..\..\HARDWARE\PID
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group CORE
    ../../CORE/: core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group FWLIB
    ../../FWLIB/: startup_stm32f10x_md.s
  group SYSTEM
    ../../SYSTEM/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group USER
    ../: main.c stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h
  group HARDWARE
    ../../HARDWARE/LED/: led.c
    ../../HARDWARE/IIC/: myiic.c
    ../../HARDWARE/OLED/: oled.c oledfont.h
    ../../HARDWARE/DS18B20/: ds18b20.c
    ../../HARDWARE/TIMER/: timer.c
    ../../HARDWARE/USART/: usart.c
    ../../HARDWARE/KEY/: key.c
    ../../HARDWARE/PID/: PidContoller.c
  group SYS
    ../../SYS/sys/: sys.c
    ../../SYS/delay/: delay.c
